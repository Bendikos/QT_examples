# Keil uVision project Project.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: Project +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\App;.\Public
  group Source Group 1
    ./: main.c
  group App
    ./app/: buzz.c key.c uart.c lcd12864.c
    ./App/: FPM10A.c
  group Public
    ./Public/: public.c
